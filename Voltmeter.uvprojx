# Keil uVision project Voltmeter.uvprojx, settings and files
target Voltmeter (6140000::V6.14::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Voltmeter
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3
  c define: STM32F446xx, USE_FULL_LL_DRIVER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group
    ./: stdout_USART.c Voltmeter.c
software components: CMSIS:CORE 5.4.0, Compiler:I/O:STDOUT 1.2.0, Board Support:Buttons 1.1.0, Board Support:LED 1.1.0, Device:STM32Cube Framework:Classic 1.7.6, Device:STM32Cube HAL:ADC 1.7.6, Device:STM32Cube HAL:Common 1.7.6, Device:STM32Cube HAL:Cortex 1.7.6, Device:STM32Cube HAL:DMA 1.7.6, Device:STM32Cube HAL:GPIO 1.7.6, Device:STM32Cube HAL:PWR 1.7.6, Device:STM32Cube HAL:RCC 1.7.6, Device:STM32Cube LL:ADC 1.2.7, Device:STM32Cube LL:Common 1.2.7, Device:STM32Cube LL:DMA 1.2.7, Device:STM32Cube LL:GPIO 1.2.7, Device:STM32Cube LL:PWR 1.2.7, Device:STM32Cube LL:RCC 1.2.7, Device:STM32Cube LL:TIM 1.2.7, Device:STM32Cube LL:UTILS 1.2.7, Device:Startup 2.6.3
